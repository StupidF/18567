# Keil uVision project 自动鱼缸.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 自动鱼缸 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\ds1302;.\LCD1602
  group Source Group 1
    ./ds1302/: ds1302.c
    ./: main.c
    ./LCD1602/: lcd1602.c
